# Keil uVision project BOOT.uvprojx, settings and files
target 工程 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BOOT +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: GD32F10X_MD
  c include: ..\CMSIS\Include;..\HardWare\Include;..\USER;..\LIB\Include;..\HardWare\Include;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000100 size 0x5000
  group USER
    ./: main.c main.h
  group CMSIS
    ../CMSIS/Source/: system_gd32f10x.c startup_gd32f10x_md.s
  group HW
    ../HardWare/Source/: gd32f10x_it.c ustart.c delay.c iic.c m24c02.c spi.c w25q64.c fmc.c boot.c
  group LIB
    ../LIB/Source/: gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_spi.c gd32f10x_fmc.c
