# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (6180000::V6.18::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: GD32F10X_MD
  c include: ..\USER;..\CMSIS\Include;..\HW\Include;..\LIB\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group CMSIS
    ../CMSIS/Source/: system_gd32f10x.c startup_gd32f10x_md.s
  group HW
    ../HW/Source/: gd32f10x_it.c usart.c
  group LIB
    ../LIB/Source/: gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_gpio.c gd32f10x_usart.c gd32f10x_dma.c
